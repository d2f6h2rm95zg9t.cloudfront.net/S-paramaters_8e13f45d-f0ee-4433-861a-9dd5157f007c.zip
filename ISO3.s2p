!Agilent Technologies,N5230A,US43500312,A.07.50.67
!Agilent N5230A: A.07.50.67
!Date: Wednesday, December 30, 2015 20:19:09
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   1601 points, 10 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -26.53 dB at 26.98 GHz (marker M1); lowest = -135.8 dB at 2.509 GHz (marker M2)
!   lowest |S11| = -59.6 dB at 1.385 GHz (marker M3), VSWR 1.00, Z = 50.1 + j0.0403 ohm
!   |S11| at or under -10 dB: 181.3 MHz to 10.21 GHz (10.03 GHz wide, 193 % of centre); 11.48 GHz to 18.95 GHz (7.475 GHz wide, 49.1 % of centre); 28.11 GHz to 30.06 GHz (1.946 GHz wide, 6.69 % of centre) (the widest 3 of 6)
!   |S22| runs from -6.3 to 0.5 dB; largest |S21 - S12| = 0.0011
!   the Smith chart shows 110 MHz to 4.034 GHz only
!   S11 on the Smith chart (normalised r, x): 110 MHz: 1.45, -0.44; 234.9 MHz: 1.08, -0.59; 4.034 GHz: 0.96, -0.03
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.1  -83.3  -85.8  -0.1
! 110 MHz  -11.9  -88.2  -97.3  -0.4
! 234.9 MHz  -11.1  -95.4  -98.8  -0.6
! 1.385 GHz  -59.6  -105.2  -117.3  -0.8
! 1.86 GHz  -26.8  -110.1  -109.5  -0.8
! 2.509 GHz  -23.7  -135.8  -123.0  -0.7
! 4.034 GHz  -32.4  -114.0  -104.0  -0.5
! 6.683 GHz  -23.6  -102.6  -102.9  -0.6
! 10.46 GHz  -9.5  -94.3  -94.9  -0.9
! 13.36 GHz  -12.9  -86.7  -85.6  -0.8
! 17.73 GHz  -16.8  -75.8  -75.6  -1.4
! 20 GHz  -7.6  -67.9  -68.4  -0.5
! 22.25 GHz  -22.0  -53.4  -53.5  -0.8
! 23.7 GHz  -5.3  -43.1  -42.9  -1.1
! 26.68 GHz  -3.8  -27.0  -27.1  -3.0
! 26.98 GHz  -4.7  -26.5  -26.7  -3.6
! 30.15 GHz  -9.2  -59.2  -59.2  -0.9
! 33.35 GHz  -2.5  -74.3  -73.7  -0.2
! 35.15 GHz  -7.8  -83.7  -81.1  -0.1
! 36.43 GHz  -3.6  -77.3  -76.3  -0.6
! 37.68 GHz  -11.9  -74.8  -74.6  -1.0
! 40 GHz  -2.5  -81.1  -95.8  -2.6
